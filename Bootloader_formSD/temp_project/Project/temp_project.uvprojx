# Keil uVision project temp_project.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: temp_project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\User\LED_Drive;..\User\KEY_Drive;..\User\EXTI_Drive;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORTS;..\User\IAP;..\User\sys;..\User\SDIO_Drive;..\User\SDCard_Drive;..\User\FATFS;..\User\USART_Dirve
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STSRTUP
    ../Libraries/CMSIS/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c stm32f10x_it.c
    ../User/LED_Drive/: LED.c
    ../User/KEY_Drive/: key_drive.c
    ../User/EXTI_Drive/: EXTI_Dirve.c
    ../User/IAP/: iap.c
    ../User/sys/: sys.c
    ../User/SDIO_Drive/: bsp_sdio_sdcard.c
    ../User/SDCard_Drive/: sdio_test.c
    ../User/USART_Dirve/: USART_Dirve.c
  group FATFS
    ../User/FATFS/: diskio.c ff.c
